# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: K1921VK01T NIIET K1921VK01T
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: K1921VK01T; OSECLK_VAL=12000000; SYSCLK_PLL; CKO_NONE; RETARGET; RETARGET_USE_UART
  ICCARM.CCIncludePath2: $PROJ_DIR$; USER; system; system/CMSIS/Core/Include; system/niietcm4_pd/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    USER/: CAN.c CPUconfig.c GPIO.c K1921VK01T_it.c main.c
  group niietcm4_pd
    system/niietcm4_pd/src/: niietcm4_adc.c niietcm4_bootflash.c niietcm4_cap.c niietcm4_dma.c niietcm4_extmem.c niietcm4_gpio.c niietcm4_irq.c niietcm4_pwm.c niietcm4_rcc.c niietcm4_rtc.c niietcm4_timer.c niietcm4_uart.c niietcm4_userflash.c niietcm4_watchdog.c
  group Startup
    system/: K1921VK01T.h startup_K1921VK01T.S system_K1921VK01T.c system_K1921VK01T.h
